# IAR project Backup of Cortex-M7.ewp, settings and files
configuration OK-STM767 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767VG ST STM32F767VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCIncludePath2: ; Include; Include\CMSIS; Include\STM32F7xx_HAL_Driver\Inc; Include\STM32F7xx_HAL_Driver\Src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OK-STM767.hex
  ILINK.IlinkOutputFile: OK-STM767.out
  ILINK.IlinkIcfFile: Linker\stm32f767xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Include
    Include/: startup_stm32f767xx.s
  group User
    ./: kit_test.c
